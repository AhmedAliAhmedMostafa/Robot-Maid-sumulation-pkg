Commit message: Remove back roller from robot model

File: urdf/no_plugins.urdf (robot description, URDF)
Before this commit: robot RoboMaid, 7 links, 6 joints
Links:
- removed link back_roller
- link front_roller: mass 0.12 -> 0.6
Joints:
- removed joint base_to_back_roller
